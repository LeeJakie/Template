# Keil uVision project stm32f407ZE.uvprojx, settings and files
target aerocraft (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407ZE +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE =8000000
  c include: .\RTE\Device\STM32F407ZE;.\RTE;.\USER\bluetooth;.\USER\send_data;.\USER\status;.\USER\auto_send_receive_data;.\USER\delay;.\USER\motor;.\USER\encoder;.\USER\steer;.\USER\infrared;.\USER\PID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./USER/main/: main.c
  group communication
    ./USER/bluetooth/: bluetooth.c
    ./USER/send_data/: send_data.c
    ./USER/auto_send_receive_data/: auto_receive_send_data.c
  group delay
    ./USER/delay/: delay.c
  group status
    ./USER/status/: status.c
  group motor
    ./USER/motor/: motor.c
  group encoder
    ./USER/encoder/: encoder.c
  group steer
    ./USER/steer/: steer.c
  group infrared
    ./USER/infrared/: infrared.c
  group PID
    ./USER/PID/: PID.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
